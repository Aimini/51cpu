# Keil uVision project 51vm.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8051 (all Variants) Generic
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: 51vm +hex
  AfterMake: srec_cat.exe 51vm.hex -Intel  -o 51vm.bin -Binary
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
