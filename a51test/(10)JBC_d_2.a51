MOV 0x80,#0xFF
MOV 0x88,#0xAB
MOV 0xA8,#0x4D
MOV 0xB8,#0xE4
MOV 0xD0,#0xF2
MOV 0xE0,#0xAF
MOV 0xF0,#0x01

SJMP L6
;P0 0xF7
L0:
JBC 0x83,L0
MOV A,#1


;TCON 0XAA
;NOTE: in stand 51, TCON在电平触发方式下， 不锁存中断，所以keil最终值是0xA3
;在模型中会锁存，所以结果应该为0xAA
L1:
JBC 0x88,L0
MOV A,#2


;IE 0x0D
L2:
JBC 0xAE,L1
MOV A,#3


;IP 0xE0
L3:
JBC 0xBA,L2
MOV A,#4


;PSW 0xF1 ( note ACC's value)
L4:
JBC 0xD1,L3
MOV A,#5


;ACC 0xAD
L5:
JBC 0xE1,L4
MOV A,#6


;B 0x00
L6:
JBC 0xF0,L5
MOV A,#255